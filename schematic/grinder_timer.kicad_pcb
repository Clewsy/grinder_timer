# Repository Clewsy/grinder_timer

File README.md:

# grinder_timer

## Rev2.1

Modelled and printed a bezel for the OLED to tidy-up the enclosure.  Modelled in [freecad][link_web_freecad], printed on a [Prusa CORE One+][link_web_prusa].  CAD files and photo [here][link_repo_bezel].

## Rev2

More information can be found at my [project page][link_clews_grinder_timer_rev2].

Improvements since rev1:

- Hardware:
	- [X] Pull-ups on I2C SDA and CLK lines.
	- [X] Drive relay with a transistor instead of direct from IO.
	- [X] Add flyback diode protection to relay coil.
	- [X] Smaller transformer.
	- [X] Smaller relay.
	- [X] Switch to SMD where possible.
	- [X] Two-sided PCB (have it fabricated instead of etching).
	- [X] Switch buttons from mushy panel-mount to tactile SMD.
	- [X] Balanced caps for the 32.768kHz crystal.
	- [X] Put grind button LED on a PWM output.
- Firmware:
	- [X] Switch from C to C++.
	- [X] New OLED driver (change from SPI SSD1306 to I2C SH1106 controller).
	- [X] Pulse/fade effect for grind button LED.
	- [X] Ability to cancel a grind once started.
	- [X] Remember selected preset after a power-cycle.

Repo contents:
- [data][link_repo_data]: Datasheets and specs for the various components used.
- [firmware][link_repo_firmware]: The code witten in C++ and developed in VSCode with the PlatformIO IDE.
- [hardware][link_repo_hardware]: KiCad files including the [schematic][link_repo_schematic] and PCB layout.
- [rev1_archive][link_repo_rev1_archive]: Firmware developed for the original grinder_timer (written in C).

Note: I used an ATmega328PB which isn't supported by the latest avr-libc package.  For the code in this repo to compile, using the included makefile, options are:
a) Modify to use an ATmega328; or
b) Manually install the *libatmega328pb.a*, *iom328pb.h* and *crtatmega328pb.o* files; or
c) Use platformio instead of the makefile.

![The completed grinder_timer_rev2.][image_grinder_timer_rev2]
---

## Rev1

This is a programmable timer tethered to a [Rancilio Rocky][link_web_rancilio_rocky] coffee grinder. The Rocky is a "dumb" grinder and electrically very simple. Basically it's an ac motor with an on/off switch and a momentary push-button to grind. This project adds an electronic timer so that repeatable grind quantities can be produced without having to stand over the grinder. Features:
- Four programmable presets (A, B, C or D) stored in EEPROM to survive powercycle.
- Left/Right buttons to select preset.
- Up/Down buttons to adjust grind duration for selected preset (0.25s increments up to 60s).
- Grind button to initiate grind and begin countdown timer.
- Oled display (128x64) to show preset menu and countdown timer.
- Aluminium enclosure.
- Single cable (3-core) tether to grinder for power and control.

The code, schematic and PCB layout are all included here on gitlab.  More information can be found at my [project page][link_clews_grinder_timer].

Proudly mentioned at [hackaday.com][link_web_hackaday_grinder_timer].

![The completed grinder_timer.][image_grinder_timer]

[link_clews_grinder_timer]:https://clews.pro/projects/grinder_timer.php
[link_clews_grinder_timer_rev2]:https://clews.pro/projects/grinder_timer_rev2.php

[link_repo_bezel]:hardware/bezel/
[link_repo_data]:data/
[link_repo_firmware]:firmware/
[link_repo_hardware]:hardware/pcb/
[link_repo_rev1_archive]:rev1_archive/
[link_repo_schematic]:hardware/schematic.pdf

[link_web_freecad]:https://www.freecad.org/
[link_web_hackaday_grinder_timer]:https://hackaday.com/2017/12/14/dumb-coffee-grinder-gets-smarter-with-time/
[link_web_prusa]:https://www.prusa3d.com/
[link_web_rancilio_rocky]:https://www.ranciliogroup.com/rancilio/rocky/rocky/

[image_grinder_timer]:images/grinder_timer_photo.jpg
[image_grinder_timer_rev2]:images/grinder_timer_rev2_photo.jpg

## KiCad design schematic/grinder_timer.kicad_pcb

Parts:
B1: D_Bridge; Diode_Bridge_Vishay_DFS
C1: 470uF; C_Elec_8x10.2
C2, C3: 0.1uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C4: 10uF; C_Elec_5x5.4
C5: 7pF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C6: 17pF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D1: 4148; D_SOD-123
J1: AVR-ISP-6; IDC-Header_2x03_P2.54mm_Vertical
J2: SERIAL; PinHeader_1x06_P2.54mm_Vertical
K1: Relay; Relay_SPDT_Finder_36.11
O1: OLED; oled
P1: MOTOR; pcb_tab
P2: ACTIVE; pcb_tab
P3: NEUTRAL; pcb_tab
Q1: NPN; SOT-223-3_TabPin2
R1, R2, R3, R5: 10k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R4: 150; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
S0: RESET; SW_Push_1P1T_NO_6x6mm_H9.5mm
S1: UP; tact
S2: DOWN; tact
S3: LEFT; tact
S4: RIGHT; tact
S5: GRIND; tact_led
T1: 1P1S; transformer_big
U1: ATmega328PB-AU; TQFP-32_7x7mm_P0.8mm
U2: 5V; SOT-223-3_TabPin2
Y1: 32.768kHz; Crystal_SMD_Abracon_ABS25-4Pin_8.0x3.8mm

Connections:
!RST: J1.5 (~RST), R3.2, S0.2, U1.29 (~RESET~/PC6)
+5V: C3.1, C4.1, D1.1 (K), J1.2 (VCC), J2.3, K1.A1, O1.1 (VCC), R1.1, R2.1, R3.1, U1.4 (VCC), U1.18 (AVCC), U2.2 (VO)
AVR_RX: J2.4, U1.30 (PD0)
AVR_TX: J2.5, U1.31 (PD1)
GND: B1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, J1.6 (GND), J2.1, O1.2 (GND), Q1.3 (E), R4.1, S0.1, S1.2, S2.2, S3.2, S4.2, S5.4, U1.5 (GND), U1.21 (GND), U2.1 (GND), Y1.2, Y1.3
MISO: J1.1 (MISO), U1.16 (PB4)
MOSI: J1.4 (MOSI), U1.15 (PB3)
unnamed: B1.1 (+), C1.1, C2.1, U2.3 (VI)
unnamed: B1.3 (~~), T1.4 (SB)
unnamed: B1.4 (~~), T1.3 (SA)
unnamed: C5.2, U1.7 (XTAL1/PB6), Y1.1
unnamed: C6.2, U1.8 (XTAL2/PB7), Y1.4
unnamed: D1.2 (A), K1.A2, Q1.2 (C)
unnamed: K1.11, P2.1, T1.1 (AA)
unnamed: K1.14, P1.1
unnamed: P3.1, T1.2 (AB)
unnamed: Q1.1 (B), R5.1
unnamed: R4.2, S5.2
unnamed: S1.1, U1.1 (PD3)
unnamed: S2.1, U1.2 (PD4)
unnamed: S3.1, U1.9 (PD5)
unnamed: S4.1, U1.10 (PD6)
unnamed: S5.1, U1.11 (PD7)
unnamed: S5.3, U1.32 (PD2)
RELAY: R5.2, U1.23 (PC0)
SCK: J1.3 (SCK), U1.17 (PB5)
SCL: O1.3 (SCL), R2.2, U1.28 (PC5)
SDA: O1.4 (SDA), R1.2, U1.27 (PC4)

Notes on the sheet:
refer to: https://clews.pro/projects/grinder_timer https://gitlab.com/clewsy/grinder_timer
grinder_timer_schematic
!DTR RX TX VCC !CTS GND
BOM ---------------------------------------- B1 - DF04S - Bridge Rectifier C1 - EMVY160ADA471MHA0G - 470uF Electrolytic Capacitor C2 - 0.1uF 1206 Ceramic Capacitor C3 - 0.1uF 1206 Ceramic Capacitor C4 - MCESL35V106M5X5.2 - 10uF Electrolytic Capacitor C5 - 7pF 1206 Ceramic Capacitor C6 - 17pF 1206 C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

Board: 2 copper layers, 75.0 x 120.0 mm, 31 parts (11 on the bottom side), 28 nets.

## KiCad design grinder_timer_kicad/grinder_timer.kicad_pcb

Parts:
Active1: TERM; SPADE_LUG
Button_Header1: CONN_01X07; Pin_Header_Straight_1x07
C1: 470uF; C_Radial_D8_L13_P3.8
C2, C3: 0.1uF; C_Rect_L7_W2.5_P5
C4: 10uF; C_Radial_D5_L11_P2
CON_ISP1: AVR-ISP-6; Pin_Header_Straight_2x03
D_RECT1: D_Bridge_+-AA; BRIDGE_RECT
IC1: ATMEGA328P-P; DIP-28_W7.62mm
Motor1: TERM; SPADE_LUG
Neutral1: TERM; SPADE_LUG
RELAY1: RM50-xx21; RELAY
RESET1: SW_Push; SW_PUSH_6mm
RTC_Crystal1: 32.768kHz; Crystal_Round_Vertical_3mm
R_RST1: 10k; Resistor_Horizontal_RM10mm
R_SCL1: 10k; Resistor_Horizontal_RM10mm
R_SDA1: 10k; Resistor_Horizontal_RM10mm
T1: TRANS
U1: SSD1306_128x64OLED; Pin_Header_Straight_1x08
U2: serial_to_usb; Pin_Header_Straight_1x06
U3: LM7805CT; TO-220

Connections:
+5V: Button_Header1.6, C3.1, C4.1, CON_ISP1.2, IC1.7 (VCC), IC1.20 (AVCC), R_RST1.1, R_SCL1.1, R_SDA1.1, U1.7 (Vin), U2.3 (VCC), U3.3 (OUT)
AVR_RX: IC1.2 ((PCINT16/RXD)PD0), U2.4 (TXO)
AVR_TX: IC1.3 ((PCINT17/TXD)PD1), U2.5 (RXI)
GND: Button_Header1.7, C1.2, C2.2, C3.2, C4.2, CON_ISP1.6, D_RECT1.2 (-), IC1.8 (GND), IC1.22 (GND), RELAY1.A1, RESET1.2, U1.3 (SA0), U1.5 ((NC)), U1.8 (GND), U2.1 (GND), U3.2 (GND)
MISO: CON_ISP1.1, IC1.18 ((PCINT4/MISO)PB4)
MOSI: CON_ISP1.4, IC1.17 ((PCINT3/OC2A/MOSI)PB3)
unnamed: Active1.1, T1.1 (PF)
unnamed: Button_Header1.1, IC1.5 ((PCINT19/OC2B/INT1)PD3)
unnamed: Button_Header1.2, IC1.6 ((PCINT20/XCK/T0)PD4)
unnamed: Button_Header1.3, IC1.11 ((PCINT21/OC0B/T1)PD5)
unnamed: Button_Header1.4, IC1.12 ((PCINT22/OC0A/AIN0)PD6)
unnamed: Button_Header1.5, IC1.13 ((PCINT23/AIN1)PD7)
unnamed: C1.1, C2.1, D_RECT1.1 (+), U3.1 (IN)
unnamed: D_RECT1.3, T1.6 (S1_1), T1.9 (S2_1)
unnamed: D_RECT1.4, T1.7 (S1_2), T1.10 (S2_2)
unnamed: IC1.9 ((PCINT6/XTAL1/TOSC1)PB6), RTC_Crystal1.2
unnamed: IC1.10 ((PCINT7/XTAL2/TOSC2)PB7), RTC_Crystal1.1
unnamed: Motor1.1, RELAY1.14
unnamed: Neutral1.1, RELAY1.11, T1.5 (P1)
RELAY: IC1.23 ((PCINT8/ADC0)PC0), RELAY1.A2
RESET: CON_ISP1.5, IC1.1 ((PCINT14/~RESET~)PC6), RESET1.1, R_RST1.2, U1.4 (RST)
SCK: CON_ISP1.3, IC1.19 ((PCINT5/SCK)PB5)
SCL: IC1.28 ((PCINT13/SCL/ADC5)PC5), R_SCL1.2, U1.2 (SCL)
SDA: IC1.27 ((PCINT12/SDA/ADC4)PC4), R_SDA1.2, U1.1 (SDA)

Notes on the sheet:
I2C Mode: 1 - SDA - Serial Data 2 - SCL - Serial Clock 3 - SA0 - Serial Address bit 0 (Address: 0b011110<SA0><R/W>) 4 - RST - Reset (Active Low, Keep High for Normal Operation) 5 - (N/C) - Not Connected (Tie Low) 6 - 3.3V - 3.3V Output (Onboard Regulator, Not Used) 7 - Vin - Supply Voltage (5V) 8 -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
1 - BUTTON_UP (PD3) 2 - BUTTON_DOWN (PD4) 3 - BUTTON_LEFT (PD5) 4 - BUTTON_RIGHT (PD6) 5 - BUTTON_GRIND (PD7) 6 - +5V_LED 7 - GND
NOTE: A 10uF electrolytinc capacitor was added to the oled across the reset pin to simulate a delayed hard reset on power-up. This can be avoided by using another GPIO output from the micro and programming a toggle of the reset pin at initialisation. Capcitor not shown here as it is to be attached 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
OLED Module with SSD1306 Driver
grinder_timer
04/12/2017
refer to https://github.com/Clewsy/grinder_timer

Board: 2 copper layers, 21 parts (0 on the bottom side), 24 nets.

## Code that names these connections

File firmware/src/main.c:

#include "usart.h"

#define BUTTON_PORT	PORTD
#define BUTTON_PINS	PIND
#define BUTTON_DDR	DDRD
#define BUTTON_LED	PD2
#define BUTTON_UP	PD3
#define BUTTON_DOWN	PD4
#define BUTTON_LEFT	PD5
#define BUTTON_RIGHT	PD6
#define BUTTON_GRIND	PD7

#define RELAY_PORT	PORTC
#define RELAY_DDR	DDRC
#define RELAY_PIN	PC0

int main(void)
{

usart_init();

BUTTON_PORT |= ((1 << BUTTON_GRIND) | (1 << BUTTON_UP) | (1 << BUTTON_DOWN) | (1 << BUTTON_LEFT) | (1 << BUTTON_RIGHT));	//Enable internal pull-ups.
BUTTON_DDR |= (1 << BUTTON_LED);		//Set as an output the pin to which the LED is connected.

RELAY_DDR |= (1 << RELAY_PIN);

uint8_t i=0;

	while (1)
	{
//		usart_print_string("testing 123\r\n");
//		usart_print_byte(i);
//		i++;
		
//		if(i>127)	PORTD |= (1 << PD2);
//		else		PORTD &= ~(1 << PD2);
		
		if(~BUTTON_PINS & (1 << BUTTON_UP))
		{
			usart_print_string("UP\r\n");
			BUTTON_PORT &= ~(1 << BUTTON_LED);
//			RELAY_PORT &= ~(1 << RELAY_PIN);
		}
		if(~BUTTON_PINS & (1 << BUTTON_DOWN))	usart_print_string("DOWN\r\n");
		if(~BUTTON_PINS & (1 << BUTTON_LEFT))	usart_print_string("LEFT\r\n");
		if(~BUTTON_PINS & (1 << BUTTON_RIGHT))	usart_print_string("RIGHT\r\n");
		if(~BUTTON_PINS & (1 << BUTTON_GRIND))
		{
			usart_print_string("GRIND\r\n");
			BUTTON_PORT |= (1 << BUTTON_LED);
//			RELAY_PORT |= (1 << RELAY_PIN);
		}	
			
		
		
	}

	return 0;	//Never reached.
}

## Commit log

2017-11-12 Initial code setup with basic makefile and USART
2017-11-13 Some basic i2c functionality and oled (SDD1306) control.
2017-11-14 Added SDD1306 driver with init and addressing functionality.
2017-11-14 Revised a note in SDD1306 header file.
2017-11-15 Tidied driver files and added oled driver functions.
2017-11-16 Implemented an RTC on Timer/Counter2 (externally connected 32.768kHz crystal).
2017-11-17 Added character and string typing functionality to the oled driver.
2017-11-17 Modified time keeping operation. Added function to print byte to oled.
2017-11-17 Test circuit with LED on output. Added enable/disable functions for timer control.
2017-11-18 Implemented a hand-written 7-segment style numerical font. Unit works as a basic countdown timer.
2017-11-19 Minor code revisions. Now including schematic (kicad).
2017-11-20 Worked on the schematic and footprints.
2017-11-21 Work on the schematic. Began PCB layout.
2017-11-22 PCB layout progress.
2017-11-23 Finished PCB layouts (first rev).
2017-11-25 Fixed a mis-wired push button on the schematic and PCB layout.
2017-11-26 First prototype PCB fabricated and somewhat successful. Major revision to improve.
2017-11-28 Minor changes - working on the hardware.
2017-11-29 Added a capacitor across oled rest pin to simulate reset toggle on power-up.
2017-12-01 Implemented a preset selection/adjustment menu system via four buttons.
2017-12-02 Implemented a sleep feature that just turns of the oled after 2 minutes.
2017-12-02 Implemented saving of presets to eeprom so as to survive powercycle.
2017-12-02 Fixed a glitch when resuming from oled sleep.
2017-12-03 Tidied code. Fixed skipped inc/dec of preset value if up/down button toggled rapidly.
2017-12-04 A few tweaks, commenting and tidying.
2017-12-04 Tidied schematic and pcb border.
2017-12-04 Added a reference schematic of the rancilio rocky coffee grinder.
2017-12-04 Renamed file
2017-12-08 Code optimisation. Fixed a glitch that caused failure if buttons actuated during powerup.
2017-12-11 Added comments and tidied up existing.
2017-12-12 Finished hardware mounting in enclosure. Opted to reverse orientation of OLED hence flipped in OLED init code.
2017-12-12 Added readme.
2017-12-12 Create LICENSE
2017-12-12 Revised readme.
2017-12-29 Added link.
2018-09-18 Added photo to README.
2019-07-24 Added a pdf of the schematic.
2020-04-09 Repo restructure and readme overhaul.
2020-04-09 Typos.
2020-04-09 Typo.
2020-07-07 Begun rev_2 (schematic underway). Restructured repo.
2020-07-08 Added rev 2 plans to readme.
2020-07-08 Working on rev_2 schematic.
2020-07-08 Fixed links (temporary).
2020-07-10 Added data, restructured schematic dir.
2020-07-10 Created custom footprints, assigned footprints to all symbols, began PCB layout.
2020-07-11 Switched transformer. Completed PCB layout. Added silkscreen logos.
2020-07-11 Changes.
2020-07-19 Fixed let tact switch pinout. Modified via sizes.
2020-07-19 Generated gerber files for fab.
2020-07-27 Initiated platformio environment for rev2 firmware (firmware directory).
2020-07-28 Most parts have arrived. PCB mostly assembled. Testing inputs and outputs (buttons, LED and relay).
2020-08-02 Button interrupts working. Started looking at PWM output to LED.
2020-08-03 Got pwm output working.
2020-08-03 Implemented led pulse effect.
2020-08-04 Barely have the OLED working. Corrected the 5V regulator part on the schematic.
2020-08-04 OLED can print bitmaps. Slowed clock and I2C speeds for stability while I debug.
2020-08-05 Lots of work, much improved i2c stability. Working OLED sh1106 drived. Added vertical scroll feature.
2020-08-06 Got the real-time clock working.
2020-08-06 Tidied header file comments and fixed header file naming convention.
2020-08-06 Need to define BAUD before including setbaud header file.
2020-08-06 Tidied comments.
2020-08-07 Improvements.
2020-08-07 Customized the font to include a decimal point.
2020-08-07 Improvements. Comments.
2020-08-08 Fonts update.
2020-08-08 Making a kinda_font to represent preset selection.
2020-08-08 Implemented preset icons and preset selection.
2020-08-08 Modified draw_box function so that boxes can now be defined by pixel height instead of page height.
2020-08-08 Typo in function declaration.
2020-08-09 Fixed box drawing for height < 8.
2020-08-09 Tidyup.
2020-08-09 Read in bytes.
2020-08-09 Added another goal.
2020-08-09 Added arrow symbols.
2020-08-09 Implemented preset selection and grind trigger.
2020-08-09 Added ability to cancel grinding by pressing any button while the motor is running.
2020-08-09 Updated.
2020-08-10 Can now set the preset values.
2020-08-10 Implemented fast change of preset when the button is held. Could be more efficient.
2020-08-10 Cleaner left, right, up and down button handling.
2020-08-10 Better enabling and disabling of the rtc.
2020-08-10 Much improved led control.
2020-08-10 Improved grind function.
2020-08-10 Comments.
2020-08-10 Directory structure.
2020-08-11 General improvements. Added sleep mode timer.
2020-08-11 General improvements. Properly iomplemented sleep mode timer.
2020-08-11 Formatting and comments.
2020-08-12 Started working on preset timer retention in eeprom.
2020-08-12 Implemented retention of selected preset at power cycle.
2020-08-12 Merged led and pulser class, header and functions.
2020-08-12 Improved initialisations.
2020-08-12 Various improvements. Added a relay class. All desired features now present.
2020-08-12 Minor.
2020-08-13 I2C pull-up values were too high, changed from 10k to 3.3k.
2020-08-13 Fixed BOM, created pdf of schematic.
2020-08-20 Fixed TWI pull-ups, switched active and neutral, tidied repo.
2020-08-20 Updated readme, rev2 is built.
2020-08-21 Fixed bug - LED now turns off while grinding.
2020-08-21 OLED config tweaks. Updated README
2020-08-22 U[dated readme.
2020-08-22 Removed gerber export.
2020-08-22 Udated readme.
2020-08-22 Fixed pull-up resistor values.
2020-08-22 Call it I2C for consistency.
2020-09-16 Switched from platformio to makefile. Improved/fixed the draw_box function.
2020-09-16 Created makefile, no longer using platformio.
2026-06-20 3d-printed bezel for oled.
2026-06-20 photos.
